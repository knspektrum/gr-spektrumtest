options:
  parameters:
    comment: |-
      Bardzo prosty projekt pozwalający sprawdzić
      działanie filtru ruchomej średniej MAV - który
      jest modułem napisanym przeze mnie(spoza oficjalnej
      dystrybucji gnuradio)
    generate_options: qt_gui
    id: noise_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: averaging
  id: variable_qtgui_range
  parameters:
    label: AVG
    rangeType: int
    start: '2'
    step: '1'
    stop: '100'
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: spektrumtest_moving_average_filter_ff_0
  id: spektrumtest_moving_average_filter_ff
  parameters:
    filter_length: averaging
  states: {}

connections:
- [analog_noise_source_x_0, '0', spektrumtest_moving_average_filter_ff_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [spektrumtest_moving_average_filter_ff_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
